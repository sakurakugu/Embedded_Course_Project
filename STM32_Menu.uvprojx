# Keil uVision project STM32_Menu.uvprojx, settings and files
target 系统定时器 (6230000::V6.23::ARMCLANG)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Menu +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\lib\CMSIS;.\lib\FWlib\inc;.\main;.\main\display;.\main\display\lcd;.\main\display\led;.\main\display\oled;.\main\key;.\main\led;.\main\spi;.\main\boards;.\main\boards\common;.\main\boards\school-STM32F103VCT6
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group docs
    ./: README.md
  group lib/FWlib
    ./lib/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ./main/: application.cpp bsp_adc.cpp bsp_AdvanceTim.cpp bsp_ESPxx.cpp bsp_exti.cpp bsp_GeneralTim.cpp bsp_i2c_ee.cpp bsp_i2c_gpio.cpp bsp_i2c_lm75.cpp bsp_JQ8900.cpp bsp_SysTick.cpp bsp_tlink.cpp bsp_usart.cpp main.cpp stm32f10x_it.cpp
  group main/display
    ./main/display/: display.cpp
    ./main/display/lcd/: gui.cpp lcd_display.cpp lcd_font.cpp touch.cpp
    ./main/display/oled/: oled_font.cpp oled_display.cpp
    ./main/display/led/: led_display.cpp led_font.cpp
  group main/key
    ./main/key/: gpio_key.cpp
  group main/led
    ./main/led/: gpio_led.cpp
  group main/spi
    ./main/spi/: bsp_spi_bus.cpp
  group main/boards/common
    ./main/boards/common/: board.cpp
  group main/boards/school-STM32F103VCT6
    ./main/boards/school-STM32F103VCT6/: config.h school-STM32F103VCT6.cpp
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS-Compiler:STDIN:ITM 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 1.0.0
