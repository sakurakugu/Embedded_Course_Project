# Keil uVision project STM32_Menu.uvprojx, settings and files
target STM32_Menu (6230000::V6.23::ARMCLANG)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Menu +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Key;..\..\User\Led;.\LingLongGUI\Gui;.\LingLongGUI\Misc;.\LingLongGUI\User;.\LingLongGUI\User\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../lib/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../lib/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ../main/: bsp.c bsp_ESPxx.c bsp_exti.c bsp_gui.c bsp_i2c_ee.c bsp_i2c_gpio.c bsp_i2c_lm75.c bsp_JQ8900.c bsp_lcd.c bsp_oled.c bsp_segdz.c bsp_spi_bus.c bsp_SysTick.c bsp_tlink.c bsp_usart.c lcdFont.c main.c oledFont.c stm32f10x_it.c touch.c
    ../main/Key/: bsp_key.c
    ../main/Led/: bsp_led.c
  group docs
    ../../: README.md
  group llGui\Gui
    ./LingLongGUI/Gui/: LL_Background.c LL_Button.c LL_ButtonEx.c LL_CheckBox.c LL_ComboBox.c LL_DateTime.c LL_Gauge.c LL_General.c LL_Gui.c LL_IconSlider.c LL_Image.c LL_Keyboard.c LL_LineEdit.c LL_ProgressBar.c LL_QRCode.c LL_Slider.c LL_Text.c LL_Window.c
  group llGui\Misc
    ./LingLongGUI/Misc/: freeRtosHeap4.c LL_Characters.c LL_Font.c LL_Lattice.c LL_Linked_List.c LL_Port.c LL_Queue.c LL_String.c LL_Timer.c LL_ZkBin.c qrcodegen.c tlsf.c
  group llGui\User
    ./LingLongGUI/User/: ui_test.c ui_testLogic.c image.c LL_User.c
    ../main/: LL_Config.c
  group llGui\User\Fonts
    ./LingLongGUI/User/Fonts/: Arial_14.c Arial_20.c Arial_9.c
